Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Номер проекта
Time: 2022-09-15T02:03:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190225_1515(x64) - Exporter 19.2.10.7 - Альтернативный интерфейс 19.2.10.7
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Sep 15 02:03:47 2022 * Host: Dell * Database: C:\Users\6EDA~1\AppData\Local\Temp\{E62BB746-7FDA-4F1C-9C32-79345994A683}\ifc * Database version: 5507 * Database creation date: Thu Sep 15 02:03:44 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Sep 15 02:03:45 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Sep 15 02:03:45 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Номер проекта
LongName: Наименование проекта; Phase: П

# IfcSite, Default
RefLatitude: 55, 44, 57, 789001; RefLongitude: 37, 38, 4, 304809; RefElevation: 0 mm

# IfcBuilding, Наименование здания
LongName: Наименование здания
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
In: Наименование здания
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: Лого, Лого:Лого:770898
In: Этаж 01
Type - Material: DKC_КрасныйЛого
Pset_BuildingElementProxyCommon - Reference: Лого

# IfcBuildingElementProxy: Текст модели:150 мм Arial (6)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 150 мм Arial

# IfcBuildingElementProxy: Текст модели:300 мм Arial
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300 мм Arial

# IfcBuildingElementProxy: Текст модели:600 мм Arial
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 600 мм Arial

# IfcFurnishingElement: Сейсмоцоколь 600x400x100мм, НВО_КНС_Сейсмоцоколь_DKC:Сейсмоцоколь 600x400x100мм:1019006
In: Этаж 01
Type - ElementType: Сейсмоцоколь 600x400x100мм; Material: DKC_Пластик_Серо-черный

# IfcFurnishingElement: Сейсмоцоколь 600x600x100мм, НВО_КНС_Сейсмоцоколь_DKC:Сейсмоцоколь 600x600x100мм:1019045
In: Этаж 01
Type - ElementType: Сейсмоцоколь 600x600x100мм; Material: DKC_Пластик_Серо-черный

# IfcFurnishingElement: Сейсмоцоколь 600x800x100мм, НВО_КНС_Сейсмоцоколь_DKC:Сейсмоцоколь 600x800x100мм:1019059
In: Этаж 01
Type - ElementType: Сейсмоцоколь 600x800x100мм; Material: DKC_Пластик_Серо-черный

# IfcFurnishingElement: Сейсмоцоколь 800x400x100мм, НВО_КНС_Сейсмоцоколь_DKC:Сейсмоцоколь 800x400x100мм:1019062
In: Этаж 01
Type - ElementType: Сейсмоцоколь 800x400x100мм; Material: DKC_Пластик_Серо-черный

# IfcFurnishingElement: Сейсмоцоколь 800x600x100мм, НВО_КНС_Сейсмоцоколь_DKC:Сейсмоцоколь 800x600x100мм:1019065
In: Этаж 01
Type - ElementType: Сейсмоцоколь 800x600x100мм; Material: DKC_Пластик_Серо-черный

# IfcFurnishingElement: Сейсмоцоколь 800x800x100мм, НВО_КНС_Сейсмоцоколь_DKC:Сейсмоцоколь 800x800x100мм:1019068
In: Этаж 01
Type - ElementType: Сейсмоцоколь 800x800x100мм; Material: DKC_Пластик_Серо-черный
